#include <dt-bindings/zmk/matrix_transform.h>

/ {
    选择了{
		zmk,kscan = &kscan0;
		zmk,matrix_transform = &default_transform;
    };
	默认变换：keymap_transform_0 {
		兼容=“zmk，矩阵变换”；
    列=<11>；
    行=<4>；
		地图=<
    RC(0,0) RC(0,1) RC(0,2) RC(0,3) RC(0,4) RC(0,5) RC(0,6) RC(0,7) RC( 0,8) RC(0,9) RC(0,10) RC(3,8)
    RC(1,0) RC(1,1) RC(1,2) RC(1,3) RC(1,4) RC(1,5) RC(1,6) RC(1,7) RC( 1,8) RC(1,9) RC(1,10)
    RC(2,0) RC(2,1) RC(2,2) RC(2,3) RC(2,4) RC(2,5) RC(2,6) RC(2,7) RC( 2,8) RC(2,9) RC(2,10)
    RC(3,0) RC(3,1) RC(3,2) RC(3,3) RC(3,4) RC(3,5) RC(3,6) RC(3,7)
		>;
	};

    kscan0: kscan_0 {
        兼容=“zmk，kscan-gpio-matrix”；
        标签=“KSCAN”；
        分布方向=“row2col”；

        通用GPIO
              = <&GPIO0 29 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio0 31 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio0 30 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio0 6 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio0 5 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio0 8 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio1 9 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio0 12 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio1 06 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio1 4 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              , <&gpio1 0 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>
              ;
    };

    右编码器：编码器右{
        兼容=“山脉山，EC11”；
        标签=“RIGHT_ENCODER”；
        a-gpios = <&gpio0 24 (GPIO_ACTIVE_HIGH | GPIO_PULL_UP)>;
        b-gpios = <&gpio0 22 (GPIO_ACTIVE_HIGH | GPIO_PULL_UP)>;
        =解析<4>；
        状态=“已禁用”；
    };

    传感器{
        兼容=“zmk，键盘映射传感器”；
        传感器= <&right_encoder>;
    };


};

&i2c0 {
	状态=“良好”；

	OLED：ssd1306@3c {
		兼容=“所罗门，ssd1306fb”；
		reg = �；
		标签=“显示”；
		宽度=<128>；
		高度=<32>；
		段偏移量 = <0>;
		页面偏移量=<0>；
		显示偏移量=<0>；
		复用部分=<31>；
		段重映射；
		com-invdir；
		后果性的；
		预充电p = "；
	};
};
